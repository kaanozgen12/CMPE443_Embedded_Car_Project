# Keil uVision project LAB_011.uvprojx, settings and files
target NXP LPC4088 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_011
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group Library
    ./Library/: SystemStructures.h Serial.c HM10.c GPIO.c Joystick.c PWM.c GPIO.h Joystick.h PWM.h LED.c LED.h Ultrasonic.c Wait.c Timer.c Ultrasonic.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1
